# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM7, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, STM32H747xx, __RTTHREAD__, USE_FULL_LL_DRIVER, RT_USING_ARM_LIBC
  c include: libraries\CMSIS\Device\ST\STM32H7xx\Include;libraries\CMSIS\Include;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;drivers;board;drivers;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\rt-thread\components\libc\posix\io\stdio;..\..\rt-thread\components\libc\posix\io\poll;..\..\rt-thread\components\libc\posix\ipc;..\..\rt-thread\components\drivers\usb\usbdevice;libraries\STM32H7xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CMSIS
    libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/rtc/: rtc.c
    ../../rt-thread/components/drivers/ipc/: completion.c ringblk_buf.c dataqueue.c workqueue.c pipe.c ringbuffer.c waitqueue.c
    ../../rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../rt-thread/components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_gpio.c drv_led.c drv_cache.c drv_usbd.c drv_lcd_dsi.c drv_sdram.c otm8009a.c drv_eth.c drv_sdio.c is42s32800j.c drv_usart.c drv_gpio.c drv_led.c drv_cache.c drv_usbd.c drv_lcd_dsi.c drv_sdram.c otm8009a.c drv_eth.c drv_sdio.c is42s32800j.c drv_usart.c
    libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h747xx.s
    board/: drv_mpu.c board.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs_fs.c dfs.c dfs_file.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c
  group Kernel
    ../../rt-thread/src/: components.c idle.c memheap.c irq.c mempool.c thread.c timer.c ipc.c kservice.c device.c object.c clock.c scheduler.c
  group rt_usbd
    ../../rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c winusb.c
    ../../rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group STM32H7xx_HAL_Driver
    libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dsi.c stm32h7xx_ll_usart.c stm32h7xx_hal_exti.c stm32h7xx_ll_crc.c stm32h7xx_hal_comp.c stm32h7xx_ll_adc.c stm32h7xx_hal_gpio.c stm32h7xx_ll_rng.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_comp.c stm32h7xx_ll_gpio.c stm32h7xx_ll_spi.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_rtc.c stm32h7xx_hal_i2c.c stm32h7xx_hal.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_ltdc.c stm32h7xx_ll_opamp.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_utils.c stm32h7xx_ll_exti.c stm32h7xx_ll_crs.c stm32h7xx_ll_lptim.c stm32h7xx_ll_dac.c stm32h7xx_ll_usb.c stm32h7xx_ll_hrtim.c stm32h7xx_hal_spi.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c stm32h7xx_hal_i2c_ex.c stm32h7xx_ll_dma.c stm32h7xx_ll_tim.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rtc.c stm32h7xx_hal_mdma.c stm32h7xx_ll_rcc.c stm32h7xx_hal_cortex.c stm32h7xx_ll_lpuart.c
